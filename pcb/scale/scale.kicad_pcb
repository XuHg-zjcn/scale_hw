# Repository XuHg-zjcn/scale_hw

## KiCad design pcb/scale/scale.kicad_pcb

Parts:
BT1: 3.7v; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
C1, C15, C35: 47uf; CP_EIA-3216-18_Kemet-A
C2, C4, C5, C8, C20, C22, C27, C30, C33, C37: 10uf; C_0805_2012Metric
C3, C6, C7, C12, C14, C21, C23, C28, C29, C41, C42: 100nf; C_0603_1608Metric
C9, C11: 100pf; C_0402_1005Metric
C10, C16, C17, C18, C19: 100nf; C_0402_1005Metric
C13, C40: 100n; C_0603_1608Metric
C24, C32, C38, C39: C_Small; C_0402_1005Metric
C25: 2.2uf; C_0402_1005Metric
C26: 10nf; C_0402_1005Metric
C31: 1uF; C_0603_1608Metric
C34: 220uf; CP_EIA-7343-31_Kemet-D
C36: 47uF; CP_EIA-3216-18_Kemet-A
C43: 2.2uf; C_0603_1608Metric
C45: 100n; C_0402_1005Metric
D1, D3: D; D_SOD-523
D2: LED; LED_0603_1608Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J3: Conn_01x04; pad4_1x1.5mm_Pitch2mm
R1, R9: 3k; R_0402_1005Metric
R2, R12: 10k; R_0402_1005Metric
R3, R4: R; R_0603_1608Metric
R5: 47k; R_0402_1005Metric
R6, R7: 100; R_0402_1005Metric
R8, R10: 1M; R_0402_1005Metric
R13, R14: 1k; R_0402_1005Metric
R15: 1; R_0603_1608Metric
R18: 10k; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: SW_Push; SW_Push_SPST_NO_Alps_SKRK
U1: TP4065; TSOT-23-5
U2: SPX3819M5-L-3-3; SOT-23-5
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: CAT3200-5; SOT-23-6
U5: CS1237; SOP-8_3.76x4.96mm_P1.27mm
U6: DS18B20; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: Crystal_Small; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C28.1, C30.1, C35.1, C43.1, J2.2, R18.1, U2.5 (OUT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U6.3 (VDD)
+5V: C12.1, C23.1, C33.1, C34.1, C36.1, C37.1, C41.2, C42.1, U4.1 (VOUT), U5.7 (VDD)
+BATT: BT1.1 (+), C3.1, C4.1, C5.1, C7.1, C15.1, C27.1, C29.1, D3.2 (A), R8.1, SW1.2, U1.3 (BAT), U2.1 (IN), U4.5 (VIN)
/AD_BAT: C45.1, R8.2, R10.1, U3.13 (PA3)
/AD_DRDO: R14.2, U3.46 (PB9)
/AD_SCLK: R13.2, U3.45 (PB8)
/APWR_EN: U3.43 (PB7), U4.3 (~SHDN)
/BOOT0: R5.1, U3.44 (BOOT0)
/CS_OLED: J2.7, U3.20 (PB2)
/DC: J2.6, U3.19 (PB1)
/DPWR_EN: R1.2, U2.3 (EN), U3.34 (PA13)
/KB_Col1: SW2.2, SW3.2, SW4.2, SW5.2, U3.28 (PB15)
/KB_Col2: SW6.2, SW7.2, SW8.2, SW9.2, U3.29 (PA8)
/KB_Col3: SW10.2, SW11.2, SW12.2, SW13.2, U3.30 (PA9)
/KB_Col4: SW14.2, SW15.2, SW16.2, SW17.2, U3.31 (PA10)
/KB_Row1: SW2.1, SW6.1, SW10.1, SW14.1, U3.27 (PB14)
/KB_Row2: SW3.1, SW7.1, SW11.1, SW15.1, U3.26 (PB13)
/KB_Row3: SW4.1, SW8.1, SW12.1, SW16.1, U3.25 (PB12)
/KB_Row4: SW5.1, SW9.1, SW13.1, SW17.1, U3.22 (PB11)
/Line_18B20: R18.2, U3.39 (PB3), U6.2 (DQ)
/MISO: U3.16 (PA6)
/MOSI: J2.4, U3.17 (PA7)
/NRST: C40.1, SW18.2, U3.7 (NRST)
/RES: J2.5, U3.18 (PB0)
/SCK: J2.3, U3.15 (PA5)
/UD+: J1.A6 (D+), J1.B6 (D+), U3.33 (PA12)
/UD-: J1.A7 (D-), J1.B7 (D-), U3.32 (PA11)
/WKUP: R2.1, R9.2, U3.10 (PA0)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C32.1, C33.2, C34.2, C35.2, C36.2, C37.2, C38.1, C39.1, C40.2, C41.1, C42.2, C43.2, C45.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.4, R2.2, R4.2, R5.2, R10.2, SW18.1, U1.2 (GND), U2.2 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.2 (GND), U5.2 (GND), U6.1 (GND), Y1.2, Y1.4
unnamed: C9.2, C10.1, R6.2, U5.4 (AINP)
unnamed: C10.2, C11.1, R7.2, U5.3 (AINN)
unnamed: C8.1, C13.1, C14.1, J3.1, R15.1, U5.1 (REFIN)
unnamed: C24.1, U3.5 (PD0), Y1.3
unnamed: C25.1, R12.1, U3.1 (VBAT)
unnamed: C26.1, U2.4 (BP)
unnamed: C31.1, U4.6 (CPOS)
unnamed: C31.2, U4.4 (CNEG)
unnamed: C32.2, U3.6 (PD1), Y1.1
unnamed: C38.2, U3.3 (PC14), Y2.2
unnamed: C39.2, U3.4 (PC15), Y2.1
unnamed: D1.1 (K), R1.1
unnamed: D1.2 (A), R9.1, SW1.1
unnamed: D2.1 (K), U1.1 (~CHRG)
unnamed: D2.2 (A), R3.2
unnamed: D3.1 (K), R12.2
unnamed: J3.2, R7.1
unnamed: J3.3, R6.1
unnamed: R4.1, U1.5 (PROG)
unnamed: R13.1, U5.5 (SCLK)
unnamed: R14.1, U5.6 (~DR/DO)
unnamed: R15.2, U5.8 (REFOUT)
VBUS: C1.1, C2.1, C6.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R3.1, U1.4 (VCC)

Notes on the sheet:
OLED电源
MCU电源

Board: 2 copper layers, 100.0 x 47.9 mm, 92 parts (48 on the bottom side), 51 nets.

## KiCad design pcb/cs1237_mod/cs1237_mod.kicad_pcb

Parts:
C1: 47uF; CP_EIA-3216-18_Kemet-A
C2, C6: 10uf; C_0805_2012Metric
C3, C5, C10, C11: 100nf; C_0603_1608Metric
C4: 100n; C_0603_1608Metric
C7: 100nf; C_0402_1005Metric
C8, C9: 100pf; C_0402_1005Metric
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: RFShield_OnePiece; Sheild_CS1237MOD
J3: Conn_01x04; pad4_1x1.5mm_Pitch2mm
L1: 10uH; L_0805_2012Metric
R1: 1; R_0603_1608Metric
R2, R3: 100; R_0402_1005Metric
R4, R5: 1k; R_0402_1005Metric
U5: CS1237; SOP-8_3.76x4.96mm_P1.27mm

Connections:
+5V: C1.1, C2.1, C3.1, C10.1, C11.1, J1.4, U5.7 (VDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.1, C10.2, C11.2, J1.1, J2.1 (Shield), J3.4, U5.2 (GND)
unnamed: C4.1, L1.2, R1.1
unnamed: C5.1, C6.1, J3.1, L1.1, U5.1 (REFIN)
unnamed: C7.1, C9.2, R2.2, U5.4 (AINP)
unnamed: C7.2, C8.1, R3.2, U5.3 (AINN)
unnamed: J1.2, R4.2
unnamed: J1.3, R5.2
unnamed: J3.2, R3.1
unnamed: J3.3, R2.1
unnamed: R1.2, U5.8 (REFOUT)
unnamed: R4.1, U5.5 (SCLK)
unnamed: R5.1, U5.6 (~DR/DO)

Board: 2 copper layers, 33.9 x 17.4 mm, 21 parts (0 on the bottom side), 13 nets.

## Commit log

2022-09-28 add pcb/cs1237_mod
2022-10-09 add 3dprint models
2022-11-03 完整PCB第一次全部连接布局
2022-11-06 PCB更大键盘间隔和更小总面积
2022-11-07 修复APWR_EN布线，ADC数字信号连接到其他引脚
2022-11-07 改进CS1237布线
2022-11-07 移动LED标签
2022-11-07 移除0402元件位号，添加NRST和BOOT0电路
2022-11-07 数字LDO输入滤波电容旋转
2022-11-08 移动5V电荷泵电容，微调布线，修复一些DRC错误
2022-11-08 添加一些GND过孔
2022-11-08 微调布线
2022-11-08 所有电源线增加到0.5mm
2022-11-08 C22移动到背面
2022-11-08 调整部分信号线为0.25mm
2022-11-08 部分信号线加粗到0.25mm，电荷泵BATT+加粗到0.5mm
2022-11-08 PCB添加文字
2022-11-08 添加GPLv3许可证复本
2022-11-09 添加接地过孔
2022-11-09 M3螺纹孔调整到3.1mm直径
2022-11-09 OLED屏排母向下移
2022-11-09 翻转NRST按键
2022-11-09 修复一些DRC错误和警告
2022-11-09 移动电源键
2022-11-09 清空电池接线附近和加粗TP4065 PROG线
2022-11-09 添加电池正极标志
2022-11-09 PCB宽度缩小到100mm
2022-11-11 电池电压检测
2022-11-11 修改CH32背后覆铜
2022-11-11 加粗电荷泵输出线到0.5mm

Notices in the files:
pcb/cs1237_mod/cs1237_mod.kicad_pcb:
GPL-3.0-or-later
pcb/scale/scale.kicad_pcb:
Copyright (c) 2022  Xu Ruijun
License: GPL-3.0-or-later
